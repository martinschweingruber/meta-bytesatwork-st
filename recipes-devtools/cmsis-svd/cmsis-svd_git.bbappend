SRC_URI:remove = "git://github.com/posborne/cmsis-svd.git;protocol=https;branch=master"
SRC_URI:prepend = "git://github.com/posborne/cmsis-svd.git;protocol=https;branch=main "
